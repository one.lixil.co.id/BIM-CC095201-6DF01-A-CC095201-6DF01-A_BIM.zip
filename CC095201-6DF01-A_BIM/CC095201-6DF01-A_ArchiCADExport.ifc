Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-09T23:56:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 09 23:56:20 2022 * Host: DESKTOP-6FF1F60 * Database: C:\Users\Artec89\AppData\Local\Temp\{A8426FA1-64AB-4DA3-A4D2-96A44F005A94}\ifc * Database version: 5507 * Database creation date: Wed Nov 09 23:56:19 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 09 23:56:20 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 09 23:56:20 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: GIX WH toilet w/o seat cover CC095201-6DF01-A, CC095201-6DF01-A_REVIT:GIX WH toilet w/o seat cover CC095201-6DF01-A:363954
In: Level 1
Material: Enamel
Pset_DistributionFlowElementCommon - Reference: GIX WH toilet w/o seat cover CC095201-6DF01-A
